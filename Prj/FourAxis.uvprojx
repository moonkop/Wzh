# Keil uVision project FourAxis.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FourAxis +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx
  c misc: --cpp
  c include: ..\CMSIS;..\Driver;..\Library\inc;..\User;..\User\devices;..\User\MAP;..\User\devices\eMPL;..\User\drivers;..\User\LCD_driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h startup_stm32f40_41xxx.s
  group Driver
    ../Driver/: stm32f4xx_it.c
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fsmc.c
  group User
    ../User/: common.c track.c common.h main.cpp main.h maincpp.h mainmap.cpp mainmap.h task.cpp task.h track.h myMath.cpp myMath.h ProcessFunctions.cpp ExceptionFunction.c Travel.cpp Treasure.cpp string.c
  group Devices
    ../User/devices/: ADC.c lcd.c LED.c RCC.c sen2020.c TIM.c USART.c USART_DMA.c motorEncoder.c KEY.c KEY.h bsp_flash.c Beep.c PhotoSwitch.c WS2811.c CameraFlash.c
  group MAP
    ../User/MAP/: map.cpp map.h mapNode.cpp mapNode.h mappath.cpp mappath.h
  group drivers
    ../User/drivers/: buttonIR.c LobotServoController.c motor.c RespCom.c FlashOperation.c
    ../User/: Actions.cpp
  group LCD_drivers
    ../User/LCD_driver/: LCD_print.c LCD_show.c
  group Flash_Driver
    ../User/Flash_driver/: Flash.c
